Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Duo_D1_EMCM-D1-8.1_INT-EN.ifc
Time: 2025-08-05T18:21:51+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Duo_D1_INT-EN:EMCM-D1-8.1, M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Duo_D1_INT-EN:EMCM-D1-8.1:1809406
In: F00
Type - Material: Color RGB 181-166-066, Color RGB 250-000-000, Color RGB 200-200-200, Color RGB 115-115-115, Color RAL 1003, Color RGB 255-255-255, Color RGB 040-040-040, Color RGB 055-055-055
Type - Other - Category: Mechanical Equipment; Family Name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Duo_D1_INT-EN; Flange Geometry: yes; Flow In Length: 307 mm; Flow Out Length: 284 mm; Total Width: 465 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 746 mm; Height: 1149 mm; Hydronic Diameter: 25.4 mm; Overflow Diameter: 25.4 mm; Refill Diameter: 12.7 mm; Suction Diameter: 25.4 mm; Use Nominal Diameter: yes; Width: 575 mm
Type - Electrical Engineering - Voltage: 230 V
Type - Electrical - Loads - Power: 600 W
Type - Identity Data - Article Description: MultiControl Modular Duo1 - 8.1 bar; Article Type: EMCM-D1-8.1; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: MultiControl Modular Duo1 - 8.1 bar; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 24.03; GLN: 8717811000007; GTIN: 8717811050637; Manufacturer: Spirotech; Manufacturer Art. No.: EMCM-D1-8.1; Manufacturer URL: https://www.spirotech.com/8717811050637; MEPcontent Class: VACUUM_DEGASSER; Model: EMCM-D1-8.1; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCM-D1-8.1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: Color RGB 115-115-115; Light Black: Color RGB 055-055-055; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCM-D1-8.1; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EMCM-D1-8.1
Other - Angle: 0 deg; Back Clearance Safe: 0 mm; Family: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Duo_D1_INT-EN; Family and Type: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Duo_D1_INT-EN: EMCM-D1-8.1; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Left Side Pipe: 231 mm; Reference Line Length: 538 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 231 mm; Top Clearance Safe: 500 mm; Type: EMCM-D1-8.1; Type Id: 1809388
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 8.15302 m2; Volume: 0.218451 m3
Identity Data - Mark: 4
Mechanical - Flow In: 0 m3/s; Flow In 2: 0 m3/s; Flow Out: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Power,Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: no; Right Clearance: 500 mm; Right Side Connection: yes; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection | PredefinedType
Port_1809406_10 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
InPort_1809406_19 | SINK | PIPE
OutPort_1809406_20 | SOURCE | PIPE
InPort_1809406_21 | SINK | PIPE
InPort_1809406_24 | SINK | PIPE
OutPort_1809406_25 | SOURCE | PIPE
